EXTRA_OECONF:aarch64 = " enable-fips enable-fips-securitychecks "
