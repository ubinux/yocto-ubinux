
COMPATIBLE_MACHINE = "qemuarm|qemuarm64|qemux86|qemuppc|qemumips|qemumips64|qemux86-64|ubinux-*|"

KMACHINE_ubinux-x86 ?= "common-pc"
KMACHINE_ubinux-x86-64 ?= "common-pc-64"
KMACHINE_ubinux-armv7 ?= "zynq"
