EXTRA_OECONF:append:class-target = " --enable-arm-neon=off "
