RDEPENDS:${PN} += "\
    qemuwrapper-cross \
    lib32-qemuwrapper-cross \
    "
