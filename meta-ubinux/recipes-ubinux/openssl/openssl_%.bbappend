EXTRA_OECONF:append = " enable-fips enable-fips-securitychecks "
