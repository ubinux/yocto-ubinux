RDEPENDS:${PN} = " \
                  nativesdk-python3-shell nativesdk-python3-fcntl nativesdk-python3-logging \
                "

