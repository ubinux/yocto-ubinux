SRC_URI = "http://archive.apache.org/dist/xml/commons/binaries/xml-commons-resolver-${PV}.tar.gz"
