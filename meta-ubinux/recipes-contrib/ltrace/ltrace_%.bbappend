FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = "file://0001-Added-aarch64_be-into-support-CPU.patch \
"
