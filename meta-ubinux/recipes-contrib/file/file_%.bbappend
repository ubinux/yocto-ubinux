PROVIDES_append_class-nativesdk = " file-replacement-nativesdk"
