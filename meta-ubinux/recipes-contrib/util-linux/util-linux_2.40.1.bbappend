PACKAGECONFIG:remove = "lastlog2"
#ALTERNATIVE_LINK_NAME[lastlog2] = "${bindir}/lastlog2"
#ALTERNATIVE_LINK_NAME[pam_lastlog2] = "${libdir}/security/pam_lastlog2.so"

