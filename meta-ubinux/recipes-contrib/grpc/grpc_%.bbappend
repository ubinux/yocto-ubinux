DEPENDS_remove_class-target = " googletest  "
