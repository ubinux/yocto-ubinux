
export TARGET_CFLAGS
export TARGET_CXXFLAGS


