FILESEXTRAPATHS_prepend := "${THISDIR}/${PN}:"

SRC_URI_append = "file://0001-Fix-compilation-with-Python-3.9-avoid-passing-encodi.patch"

