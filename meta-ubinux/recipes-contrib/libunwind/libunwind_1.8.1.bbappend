inherit multilib_script
MULTILIB_SCRIPTS = "${PN}:${libexecdir}/libunwind/check-namespace.sh \
                    ${PN}:${libexecdir}/libunwind/test-runner "

