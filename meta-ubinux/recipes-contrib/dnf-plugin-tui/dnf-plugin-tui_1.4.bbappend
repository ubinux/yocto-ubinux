FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "file://0001-tui.py-dnf-has-something-error-to-get-group-infomati.patch "
