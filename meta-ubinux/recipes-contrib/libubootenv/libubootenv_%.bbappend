RRECOMMENDS_${PN}-bin_remove_class-target = "u-boot-default-env"
