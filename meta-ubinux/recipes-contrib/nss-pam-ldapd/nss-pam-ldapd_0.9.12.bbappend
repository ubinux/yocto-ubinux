EXTRA_OEMAKE += "CC='${CC} -std=c99 '"
