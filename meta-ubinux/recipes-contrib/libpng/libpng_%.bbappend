EXTRA_OECONF:append:class-target = " --enable-hardware-optimizations=on "
