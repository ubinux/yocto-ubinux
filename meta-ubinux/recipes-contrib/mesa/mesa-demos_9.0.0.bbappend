FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

SRC_URI += "\
           file://0001-meson-fix-glx-detection-without-glvnd.patch \
           "

