RDEPENDS_${PN} += " bash"
