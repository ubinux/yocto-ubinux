RDEPENDS_${PN} += " bash"
RDEPENDS_${SRCNAME}-engine += " bash"
