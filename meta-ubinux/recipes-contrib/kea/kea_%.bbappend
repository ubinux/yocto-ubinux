inherit multilib_script
MULTILIB_SCRIPTS += "${PN}:${sysconfdir}/kea/kea-dhcp6.conf "

