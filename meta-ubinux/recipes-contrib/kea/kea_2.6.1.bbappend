FILESEXTRAPATHS:prepend := "${THISDIR}/kea:"

SRC_URI += "file://0001-There-is-a-conflict-of-kea-dhcp6conf-between-kea-and-l.patch "
