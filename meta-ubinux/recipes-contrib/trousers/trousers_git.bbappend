FILES_${PN} += "${systemd_unitdir}/*"
