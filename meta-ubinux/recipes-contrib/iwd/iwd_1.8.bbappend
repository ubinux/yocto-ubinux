FILES_${PN} += " \
    /lib/modules-load.d \
"
