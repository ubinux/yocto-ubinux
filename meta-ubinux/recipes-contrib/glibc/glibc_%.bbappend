do_install_armmultilib:append () {
       oe_multilib_header finclude/math-vector-fortran.h
}
