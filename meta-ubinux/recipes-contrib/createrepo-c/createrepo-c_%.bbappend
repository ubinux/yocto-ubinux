INSANE_SKIP_${PN} += "dev-deps"
