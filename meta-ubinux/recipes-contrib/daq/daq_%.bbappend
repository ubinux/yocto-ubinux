inherit multilib_script
MULTILIB_SCRIPTS += "${PN}:${bindir}/daq-modules-config "

