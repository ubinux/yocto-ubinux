inherit multilib_script

MULTILIB_SCRIPTS = "${PN}:${bindir}/find-debuginfo"

