deltask do_spdx
