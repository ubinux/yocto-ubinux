FILESEXTRAPATHS:prepend := "${THISDIR}/openvswitch:"

SRC_URI += "file://0001-Fix-install-error.patch "

