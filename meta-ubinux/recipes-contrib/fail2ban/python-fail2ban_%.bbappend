RDEPENDS_${PN} = "iptables sqlite3 ${PYTHON_PN} ${PYTHON_PN}-pyinotify"

