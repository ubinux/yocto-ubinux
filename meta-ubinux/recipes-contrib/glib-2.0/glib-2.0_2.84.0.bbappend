RDEPENDS:${PN}-ptest:remove:libc-glibc = "\
            locale-base-c \
           "

