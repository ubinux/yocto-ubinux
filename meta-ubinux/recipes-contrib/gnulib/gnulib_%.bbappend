deltask do_deploy_archives
deltask do_spdx
