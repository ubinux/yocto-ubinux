CVE_PRODUCT = "oracle_berkeley_db berkeley_db"
