inherit multilib_script
MULTILIB_SCRIPTS = "${PN}:${sysconfdir}/opkg/arch.conf"
