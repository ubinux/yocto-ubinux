RDEPENDS_${PN} += "\
    nativesdk-libnewt-python \
    nativesdk-createrepo-c \
    nativesdk-gpgme \
    nativesdk-update-rc.d \
    "

