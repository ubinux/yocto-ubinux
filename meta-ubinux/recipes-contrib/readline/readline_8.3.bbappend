FILESEXTRAPATHS:prepend := "${THISDIR}/readline:"

SRC_URI += "file://0001-Readline-8.3-patch-1-fix-for-readline-event-hook.patch "
