DEPENDS:append = " bash "

