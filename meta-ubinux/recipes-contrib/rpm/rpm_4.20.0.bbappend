FILESEXTRAPATHS:append := ":${THISDIR}/rpm"
SRC_URI:append = " file://0001-Set-RPM_PLUGINDIR-in-top-level-CMakeLists.txt.patch "
